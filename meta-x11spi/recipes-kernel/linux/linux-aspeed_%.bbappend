FILESEXTRAPATHS_prepend := "${THISDIR}/linux-aspeed:"
SRC_URI += "file://0001-linux-aspeed-add-supermicro-x11spi-device-tree.patch"
